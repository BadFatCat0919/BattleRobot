# Keil uVision project CAUCKOF_ControlBoard.uvprojx, settings and files
target CAUCKOF_ControlBoard (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAUCKOF_ControlBoard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SOLGUI;..\SOLGUI\Font;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\FLASH;..\HARDWARE\USART;..\HARDWARE\BLUETOOTH;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\CONTROL;..\ANO;..\HARDWARE\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c menu.c data.c modes.c
  group CONTROL
    ../CONTROL/: control.c action.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_exti.c
  group SOLGUI
    ../SOLGUI/: SOLGUI_Common.c SOLGUI_GBasic.c SOLGUI_Hardware.c SOLGUI_Menu.c SOLGUI_Picture.c SOLGUI_Printf.c SOLGUI_Widget.c
    ../SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
  group ANO
    ../ANO/: ANO.c
  group README
    ../: README.TXT
